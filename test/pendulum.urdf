Commit message: tests PD tuning via distributed CG

File: test/pendulum.urdf (robot description, URDF)
Before this commit: robot pendulum, 2 links, 1 joints
Links:
- link rod: mass 1.0 -> 10.0
